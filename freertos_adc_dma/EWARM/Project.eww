<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\freertos_adc_dma.ewp</path>
  </project>
  <batchBuild />
</workspace>
