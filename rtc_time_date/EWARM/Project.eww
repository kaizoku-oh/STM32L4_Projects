<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\rtc_time_date.ewp</path>
  </project>
  <batchBuild />
</workspace>
