<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\l4uartdma.ewp</path>
  </project>
  <batchBuild />
</workspace>
